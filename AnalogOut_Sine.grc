<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>102400</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>sine_freq</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>3000</value></param>
<param><key>min</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>AD2_AnalogOut_Sine_AD2_AnalogOut_Sine_i</key>
<param><key>id</key><value>AD2_AnalogOut_Sine_AD2_AnalogOut_Sine_i_0</value></param>
<param><key>amplituide</key><value>1.41</value></param>
<param><key>channel</key><value>0</value></param>
<param><key>offset</key><value>1.41</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0_0</value></param>
<param><key>const</key><value>sine_freq</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>maxoutbuf</key><value>1024</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>int</value></param>
</block>
<connection><source_block_id>analog_const_source_x_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>AD2_AnalogOut_Sine_AD2_AnalogOut_Sine_i_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
