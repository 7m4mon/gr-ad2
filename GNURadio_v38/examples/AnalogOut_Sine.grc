options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '102400'
  states: {}
- name: sine_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '100'
    stop: '10000'
    value: '1000'
  states: {}
- name: ad2_AD2_AnalogOut_Sine_i_0
  id: ad2_AD2_AnalogOut_Sine_i
  parameters:
    amplituide: '1'
    channel: '0'
    offset: '1'
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: sine_freq
    type: int
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    maxoutbuf: '1024'
    samples_per_second: samp_rate
    type: int
  states: {}

connections:
- [analog_const_source_x_0_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', ad2_AD2_AnalogOut_Sine_i_0, '0']

metadata:
  file_format: 1
