options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: emphasis_sec
  id: variable
  parameters:
    value: '0'
  states: {}
- name: local_freq
  id: variable
  parameters:
    value: '66000'
  states: {}
- name: max_deviation
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: samp_rate_af
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: AD2_AnalogIn_Record_AD2_AnalogIn_Record_f_0
  id: AD2_AnalogIn_Record_AD2_AnalogIn_Record_f
  parameters:
    channel: '0'
    hz_acq: samp_rate
    n_samples: samp_rate
    v_range: '1.0'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '4000'
    audio_stop: '5000'
    chan_rate: samp_rate
    deviation: max_deviation
    gain: '1.0'
    tau: emphasis_sec
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate_af
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: max_deviation
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: local_freq
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(0.1, samp_rate, 30e3, 10e3)
    type: fcf
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '4000'
    decim: int(samp_rate/samp_rate_af)
    gain: '1'
    samp_rate: samp_rate_af
    type: fir_filter_fff
    width: '1000'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    ncols: '256'
    nrows: '256'
    samp_rate: samp_rate_af
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '256'
    srate: samp_rate_af
    type: float
  states: {state: disabled}

connections:
- [AD2_AnalogIn_Record_AD2_AnalogIn_Record_f_0, '0', blocks_throttle_0, '0']
- [analog_fm_demod_cf_0, '0', low_pass_filter_1, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_fm_demod_cf_0, '0']
- [low_pass_filter_1, '0', audio_sink_0, '0']
- [low_pass_filter_1, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
